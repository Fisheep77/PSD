# Keil uVision project MainControl.uvprojx, settings and files
target MainControl (6230000::V6.23::ARMCLANG)
  device: STM32G431CBTx STMicroelectronics
  pack: Keil.STM32G4xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x801FFFF)  CLOCK(8000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: MainControl +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=6 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32G431xx
  c include: ../Core/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc;../Drivers/STM32G4xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32G4xx/Include;../Drivers/CMSIS/Include;../Drivers/BSP;../Drivers/BSP/inc;../Drivers/DMP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application/MDK-ARM
    ./: startup_stm32g431xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c dma.c i2c.c tim.c usart.c stm32g4xx_it.c stm32g4xx_hal_msp.c
  group Drivers/BSP
    ../Drivers/BSP/: bsp.c bsp.h
    ../Drivers/BSP/src/: bsp_keyled.c bsp_user_lib.c bsp_filter.c bsp_pid.c bsp_uart_dma.c bsp_tim.c bsp_i2c_master.c bsp_bluetooth.c bsp_motor_control.c bsp_mpu6050.c bsp_body_angle_control.c bsp_psd.c
  group Drivers/DMP
    ../Drivers/DMP/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Drivers/STM32G4xx_HAL_Driver
    ../Drivers/STM32G4xx_HAL_Driver/Src/: stm32g4xx_hal_i2c.c stm32g4xx_hal_i2c_ex.c stm32g4xx_hal.c stm32g4xx_hal_rcc.c stm32g4xx_hal_rcc_ex.c stm32g4xx_hal_flash.c stm32g4xx_hal_flash_ex.c stm32g4xx_hal_flash_ramfunc.c stm32g4xx_hal_gpio.c stm32g4xx_hal_exti.c stm32g4xx_hal_dma.c stm32g4xx_hal_dma_ex.c stm32g4xx_hal_pwr.c stm32g4xx_hal_pwr_ex.c stm32g4xx_hal_cortex.c stm32g4xx_hal_tim.c stm32g4xx_hal_tim_ex.c stm32g4xx_hal_uart.c stm32g4xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32g4xx.c
software components: CMSIS:CORE 6.1.0, CMSIS:DSP 1.16.2, Utilities:perf_counter:Core 2.4.0
