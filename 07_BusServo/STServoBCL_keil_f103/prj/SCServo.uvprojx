# Keil uVision project SCServo.uvprojx, settings and files
target SCServo (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: SCServo +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER,USE_USART2_
  c include: ..\SCSLib;..\STM32F10x\STM32F10x_StdPeriph_Driver\inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group SCSLib
    ../SCSLib/: uart.c SC.c SCSerail.c ST.c
  group STM32F10x
    ../STM32F10x/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c system_stm32f10x.c
    ../STM32F10x/startup/: startup_stm32f10x_md.s
  group examples
    ../examples/: ProgramEprom.c FeedBack.c CalibrationOfs.c Ping.c WritePos.c main.c wiring.c Broadcast.c RegWritePos.c SyncWritePos.c WriteSpe.c SyncRead.c
software components: CMSIS:CORE 4.3.0
